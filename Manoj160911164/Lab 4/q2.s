	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R2,=ANS
	LDR R0,=HEX
	MOV R4,#0X08
	MOV R5,#0
up	LDRB R1,[R0],#1
	BL ascii_hex
	LSL R1,R5
	ORR R6,R1
	ADD R5,#0X04
	SUB R4,#0X01
	TEQ R4,#0
	BNE up
	STR R6,[R2]
HERE B HERE
ascii_hex
	CMP R1,#0X41
	BLO down
	SUB R1,#0X07
down SUB R1,#0X30
	BX LR
HEX DCB 0x35,0X34,0X32,0X31,0X41,0X31,0X42,0X39
	AREA mydata, DATA, READWRITE
ANS DCD 0
 END