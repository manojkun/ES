	AREA RESET, DATA, READONLY ; bcd to hex
	EXPORT __Vectors
__Vectors
	DCD 0x40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=HEX
	LDR R1,[R0]
	MOV R5,#0 ; ANS
	MOV R7,#32
UP
	BL DIV
	CMP R1,#0
	BNE UP
	LSR R5,R7
	LDR R0,=BCD
	STR R5,[R0]
STOP B STOP
DIV
	MOV R3,#0 ;QUO
PU
	CMP R1,#10
	BLO DOWN
	SUB R1,#10
	ADD R3,#1
	B PU
DOWN	
	ORR R5,R1
	ROR R5,#4
	SUB R7,#4
	MOV R1,R3
	BX LR
HEX DCD 0x01234567
	AREA mydata, DATA, READWRITE
BCD DCD 0, 0
 END