	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
	
Reset_Handler
	LDR R0,=NUM1
	LDR R1,=NUM2
	LDR R3,=RES
	LDR R4,[R0]
	LDR R5,[R1]
	BL gcd
	STR R4,[R3]
STOP B STOP
gcd	MOV R9,#0
UP	CMP R4,R5
	BXEQ LR
	SUBLO R5,R4
	SUBGT R4,R5
	B UP
NUM1 DCD 4
NUM2 DCD 8
	AREA mydata,DATA,READWRITE
RES DCD 0
	END