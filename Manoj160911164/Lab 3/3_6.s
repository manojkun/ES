	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM1
	LDR R0,[R0]
	LDR R1,=NUM2
	LDR R1,[R1]
	LDR R2,=QUO
	MOV R4,R0 ;a1
	MOV R5,R1 ;b1
	
UP	CMP R4,R5
	BEQ ext
	ADDLO R4,R0
	ADDHS R5,R1
	B UP
ext	STR R4,[R2]
STOP B STOP
NUM1 DCD 0x5
NUM2 DCD 0x4
	AREA mydata,DATA,READWRITE
QUO DCD 0
	END